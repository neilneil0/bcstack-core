# Keil uVision project Project.uvproj, settings and files
target STM32F401-Discovery (ARM-ADS)
  device: STM32F401CC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x08000000-0x0803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F401-Discovery
  c flags: OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xC,USE_STM32F401_DISCO,HAVE_SHELL,INIT_CMD_NUM=0
  c misc: --C99 --gnu
  c include: ..\Inc;..\..\stm32f4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\stm32f4\Drivers\STM32F4xx_HAL_Driver\inc;..\..\stm32f4\Drivers\BSP\STM32F401-Discovery;..\..\stm32f4\User;..\..\..\..\bluetooth\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32F401-Discovery
    ../../stm32f4/Drivers/BSP/STM32F401-Discovery/: stm32f401_discovery.c
  group stm32f4xx/user
    ../../stm32f4/User/: system_stm32f4xx.c stm32f4xx_hal_conf.h stm32f4xx_it.h
  group stm32f4xx/hal
    ../../stm32f4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group stm32f401/startup
    ./: startup_stm32f401xc.s
  group main
    ../source/: main.c bt_uart.c retarget.c
  group app
    ../../../../apps/demo/: btdemo.c
  group bluetooth
    ../../../../bluetooth/stack/gatt/: accel-service.c battery-service.c blood-pressure-service.c devinfo-service.c gatt.c led-service.c
    ../../../../bluetooth/stack/hci/bcsp/: hci-bcsp.c ubcsp.c
    ../../../../bluetooth/stack/hci/: hcid.c
    ../../../../bluetooth/stack/l2cap/: l2cap.c
    ../../../../bluetooth/stack/vport/: vport.c
    ../../../../bluetooth/utils/: debug.c
